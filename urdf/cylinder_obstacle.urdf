Commit message: Add cylinder_obstacle files

File: urdf/cylinder_obstacle.urdf (robot description, URDF)
Before this commit: robot obstacle, 1 links, 0 joints
Links:
- link obstacle_base: geometry collision cylinder length=0.4 radius=0.5; visual cylinder length=0.4 radius=0.5
