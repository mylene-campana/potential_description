Commit message: Update to viewer

File: urdf/obstacles_concaves.urdf (robot description, URDF)
Before this commit: robot obstacles, 14 links, 13 joints
Links:
- link obstacle_base: geometry collision box size=0.8 1.8 0.42; visual box size=0.8 1.8 0.42
